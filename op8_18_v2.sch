v {xschem version=3.0.0 file_version=1.1}
G {}
V {}
S {}
E {}
C {iopin.sym} 170 240 0 1 {name=p0 lab=In+
}
C {iopin.sym} 350 240 0 1 {name=p1 lab=In-
}
C {iopin.sym} 830 260 0 1 {name=p2 lab=out
}
C {iopin.sym} 820 -20 0 1 {name=p3 lab=VDD
}
C {iopin.sym} 820 550 0 1 {name=p4 lab=VSS
}
C {iopin.sym} -80 260 0 1 {name=p5 lab=bias
}
C {PMOS_MIN.sym} 0 40 0 1 {name=M1 l=5u w=15u m=2}
C {PMOS_MIN.sym} 0 160 0 1 {name=M2 l=2u w=20u m=5}
C {PMOS_MIN.sym} 30 40 0 0 {name=M3 l=5u w=15u m=2}
C {PMOS_MIN.sym} 30 160 0 0 {name=M4 l=2u w=20u m=5}
C {NMOS_MIN.sym} 110 380 0 1 {name=M5 l=2u w=20u m=5}
C {NMOS_MIN.sym} 110 480 0 1 {name=M6 l=2u w=20u m=5}
C {NMOS_MIN.sym} 140 380 0 0 {name=M7 l=2u w=20u m=5}
C {NMOS_MIN.sym} 140 480 0 0 {name=M8 l=2u w=20u m=5}
C {NMOS_MIN.sym} 170 240 0 0 {name=M9 l=5u w=20u m=5}
C {NMOS_MIN.sym} 350 240 0 1 {name=M10 l=5u w=20u m=5}
C {PMOS_MIN.sym} 340 40 0 0 {name=M11 l=5u w=15u m=2}
C {PMOS_MIN.sym} 340 170 0 0 {name=M12 l=2u w=20u m=5}
C {PMOS_MIN.sym} 440 40 0 0 {name=M13 l=5u w=15u m=2}
C {PMOS_MIN.sym} 440 170 0 0 {name=M14 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 380 0 1 {name=M15 l=2u w=20u m=5}
C {NMOS_MIN.sym} 420 480 0 1 {name=M16 l=5u w=10u}
C {NMOS_MIN.sym} 440 380 0 0 {name=M17 l=2u w=20u m=5}
C {NMOS_MIN.sym} 440 480 0 0 {name=M18 l=5u w=10u}
C {PMOS_MIN.sym} 520 270 0 1 {name=M19 l=1u w=40u m=6}
C {NMOS_MIN.sym} 530 480 0 0 {name=M20 l=5u w=20u m=3}
C {PMOS_MIN.sym} 610 40 0 1 {name=M21 l=1u w=40u m=2}
C {PMOS_MIN.sym} 610 140 0 1 {name=M22 l=1u w=40u m=2}
C {NMOS_MIN.sym} 680 270 0 1 {name=M23 l=1u w=40u m=3}
C {PMOS_MIN.sym} 660 100 0 0 {name=M24 l=5u w=10u m=1}
C {NMOS_MIN.sym} 740 400 0 1 {name=M25 l=1u w=40u}
C {NMOS_MIN.sym} 740 480 0 1 {name=M26 l=1u w=40u}
C {PMOS_MIN.sym} 760 200 0 0 {name=M27 l=1u w=20u m=15}
C {NMOS_MIN.sym} 760 330 0 0 {name=M29 l=1u w=20u m=5}
C {HR_POLY_MIN.sym} -40 290 0 0 {name=R1 value=350k}
C {HR_POLY_MIN.sym} 70 260 0 0 {name=R2 value=17.5k}
C {CAP_MIN.sym} 730 200 0 0 {name=C1 value=\{ccap\}}
C {CAP_MIN.sym} 730 330 2 0 {name=C2 value=\{ccap\}}
N 70 -20 -40 -20 {}
N 380 -20 70 -20 {}
N 480 -20 380 -20 {}
N 570 -20 480 -20 {}
N 700 -20 570 -20 {}
N 800 -20 700 -20 {}
N 820 -20 800 -20 {}
N -40 10 -40 -20 {}
N -40 10 -50 10 {}
N 70 10 70 -20 {}
N 80 10 70 10 {}
N 380 10 380 -20 {}
N 390 10 380 10 {}
N 480 10 480 -20 {}
N 490 10 480 10 {}
N 570 10 570 -20 {}
N 570 10 560 10 {}
N -50 40 -50 10 {}
N -40 40 -50 40 {}
N 10 40 0 40 {}
N 30 40 10 40 {}
N 80 40 80 10 {}
N 80 40 70 40 {}
N 390 40 390 10 {}
N 390 40 380 40 {}
N 490 40 490 10 {}
N 490 40 480 40 {}
N 560 40 560 10 {}
N 570 40 560 40 {}
N 700 70 700 -20 {}
N 710 70 700 70 {}
N 570 80 570 70 {}
N 610 80 610 40 {}
N 610 80 570 80 {}
N 10 100 10 40 {}
N 340 100 340 40 {}
N 340 100 10 100 {}
N 440 100 440 40 {}
N 440 100 340 100 {}
N 660 100 440 100 {}
N 710 100 710 70 {}
N 710 100 700 100 {}
N 570 110 570 80 {}
N 480 120 480 70 {}
N 480 120 210 120 {}
N -40 130 -40 70 {}
N 70 130 70 70 {}
N 380 140 380 70 {}
N 380 140 310 140 {}
N 480 140 480 120 {}
N 560 140 560 40 {}
N 570 140 560 140 {}
N -50 160 -50 40 {}
N -40 160 -50 160 {}
N 10 160 10 100 {}
N 10 160 0 160 {}
N 30 160 10 160 {}
N 80 160 80 40 {}
N 80 160 70 160 {}
N 340 170 340 100 {}
N 390 170 390 40 {}
N 390 170 380 170 {}
N 440 170 440 100 {}
N 490 170 490 40 {}
N 490 170 480 170 {}
N 800 170 800 -20 {}
N 810 170 800 170 {}
N 570 180 570 170 {}
N 610 180 610 140 {}
N 610 180 570 180 {}
N 640 200 480 200 {}
N 730 200 640 200 {}
N 760 200 730 200 {}
N 810 200 810 170 {}
N 810 200 800 200 {}
N 210 210 210 120 {}
N 310 210 310 140 {}
N -40 220 -40 190 {}
N 10 220 10 160 {}
N 10 220 -40 220 {}
N 300 240 210 240 {}
N 310 240 300 240 {}
N 480 240 480 200 {}
N 640 240 640 200 {}
N -40 260 -40 220 {}
N -40 260 -80 260 {}
N 70 260 70 190 {}
N 140 260 70 260 {}
N 800 260 800 230 {}
N 800 260 730 260 {}
N 830 260 800 260 {}
N 260 270 210 270 {}
N 310 270 260 270 {}
N 390 270 390 170 {}
N 480 270 390 270 {}
N 570 270 570 180 {}
N 570 270 520 270 {}
N 640 270 630 270 {}
N 700 270 700 130 {}
N 700 270 680 270 {}
N 730 270 730 260 {}
N -40 290 -40 260 {}
N 800 300 800 260 {}
N 70 330 70 320 {}
N 120 330 70 330 {}
N 380 330 380 200 {}
N 430 330 380 330 {}
N 480 330 480 300 {}
N 640 330 640 300 {}
N 640 330 480 330 {}
N 730 330 640 330 {}
N 760 330 730 330 {}
N 810 330 800 330 {}
N 70 350 70 330 {}
N 260 350 260 270 {}
N 260 350 180 350 {}
N 380 350 380 330 {}
N 480 350 480 330 {}
N 700 360 700 270 {}
N 740 360 700 360 {}
N 810 360 810 330 {}
N 810 360 800 360 {}
N 700 370 700 360 {}
N 70 380 60 380 {}
N 140 380 140 260 {}
N 140 380 110 380 {}
N 190 380 180 380 {}
N 380 380 370 380 {}
N 430 380 430 330 {}
N 430 380 420 380 {}
N 440 380 430 380 {}
N 490 380 480 380 {}
N 700 400 690 400 {}
N 740 400 740 360 {}
N 120 430 120 330 {}
N 530 430 120 430 {}
N 700 440 700 430 {}
N 740 440 700 440 {}
N 70 450 70 410 {}
N 180 450 180 410 {}
N 380 450 380 410 {}
N 480 450 480 410 {}
N 570 450 570 270 {}
N 700 450 700 440 {}
N 60 480 60 380 {}
N 70 480 60 480 {}
N 120 480 120 430 {}
N 120 480 110 480 {}
N 140 480 120 480 {}
N 190 480 190 380 {}
N 190 480 180 480 {}
N 370 480 370 380 {}
N 380 480 370 480 {}
N 430 480 430 380 {}
N 430 480 420 480 {}
N 440 480 430 480 {}
N 490 480 490 380 {}
N 490 480 480 480 {}
N 530 480 530 430 {}
N 580 480 570 480 {}
N 690 480 690 400 {}
N 700 480 690 480 {}
N 740 480 740 440 {}
N 60 510 60 480 {}
N 70 510 60 510 {}
N 190 510 190 480 {}
N 190 510 180 510 {}
N 370 510 370 480 {}
N 380 510 370 510 {}
N 490 510 490 480 {}
N 490 510 480 510 {}
N 580 510 580 480 {}
N 580 510 570 510 {}
N 690 510 690 480 {}
N 700 510 690 510 {}
N -40 550 -40 350 {}
N 70 550 70 510 {}
N 70 550 -40 550 {}
N 180 550 180 510 {}
N 180 550 70 550 {}
N 300 550 300 240 {}
N 300 550 180 550 {}
N 380 550 380 510 {}
N 380 550 300 550 {}
N 480 550 480 510 {}
N 480 550 380 550 {}
N 570 550 570 510 {}
N 570 550 480 550 {}
N 630 550 630 270 {}
N 630 550 570 550 {}
N 700 550 700 510 {}
N 700 550 630 550 {}
N 800 550 800 360 {}
N 800 550 700 550 {}
N 820 550 800 550 {}
